# IAR project Project.ewp, settings and files
configuration STM32100B-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\CMSIS; ..\StdPeriph_Driver\inc; ..\USB\CONFIG; ..\USB\LIB
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c
  group USB
    ../USB/LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USBCFG
    ../USB/CONFIG/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group User
    ../: delay.c FAT16.c key.c main.c stm32f10x_it.c stmflash.c
